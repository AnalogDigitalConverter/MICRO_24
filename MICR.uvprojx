# Keil uVision project MICR.uvprojx, settings and files
target mbed_NUCLEO_L432KC (6160000::V6.16::ARMCLANG)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mbed_NUCLEO_L432KC
  AfterMake: fromelf --bin -o "$L@L.bin" "!L"
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6
  c define: __MICROLIB ARM_MATH_CM4 DEVICE_ANALOGIN=1 DEVICE_ANALOGOUT=1 DEVICE_CAN=1 DEVICE_CRC=1 DEVICE_FLASH=1 DEVICE_I2C=1 DEVICE_I2CSLAVE=1 DEVICE_I2C_ASYNCH=1 DEVICE_INTERRUPTIN=1 DEVICE_LPTICKER=1 DEVICE_MPU=1 DEVICE_PORTIN=1 DEVICE_PORTINOUT=1 DEVICE_PORTOUT=1 DEVICE_PWMOUT=1 DEVICE_RESET_REASON=1 DEVICE_RTC=1 DEVICE_SERIAL=1 DEVICE_SERIAL_ASYNCH=1 DEVICE_SERIAL_FC=1 DEVICE_SLEEP=1 DEVICE_SPI=1 DEVICE_SPISLAVE=1 DEVICE_SPI_ASYNCH=1 DEVICE_STDIO_MESSAGES=1 DEVICE_TRNG=1 DEVICE_USTICKER=1 DEVICE_WATCHDOG=1 EXTRA_IDLE_STACK_REQUIRED MBED_RAM1_SIZE=0x4000 MBED_RAM1_START=0x10000000 MBED_RAM_SIZE=0xc000 MBED_RAM_START=0x20000000 MBED_ROM_SIZE=0x40000 MBED_ROM_START=0x8000000 MBED_RTOS_SINGLE_THREAD MBED_TICKLESS MULADDC_CANNOT_USE_R7 NDEBUG STM32L432xx TARGET_CORTEX TARGET_CORTEX_M TARGET_LIKE_CORTEX_M4 TARGET_LIKE_MBED TARGET_M4 TARGET_MCU_STM32 TARGET_MCU_STM32L4 TARGET_MCU_STM32L432xC TARGET_NAME=NUCLEO_L432KC TARGET_NUCLEO_L432KC TARGET_RELEASE TARGET_RTOS_M4_M7 TARGET_STM TARGET_STM32L4 TARGET_STM32L432xC TOOLCHAIN_ARM TOOLCHAIN_ARMC6 TOOLCHAIN_ARM_STD TRANSACTION_QUEUE_SIZE_SPI=2 USE_FULL_LL_DRIVER USE_HAL_DRIVER __CMSIS_RTOS __CORTEX_M4 __FPU_PRESENT=1 __MBED_CMSIS_RTOS_CM __MBED__=1
  c misc: -include ../../../mbed/mbed_config.h -mcpu=cortex-m4 -mfloat-abi=hard -mfpu=fpv4-sp-d16 -mthumb --target=arm-arm-none-eabi -fno-c++-static-destructors -fdata-sections -fno-exceptions -Wno-armcc-pragma-anon-unions -Wno-armcc-pragma-push-pop -Wno-deprecated-register -Wno-reserved-user-defined-literal
  c include: .;../../../mbed/mbed-os;../../../mbed/mbed-os/cmsis;../../../mbed/mbed-os/cmsis/CMSIS_5;../../../mbed/mbed-os/cmsis/CMSIS_5/CMSIS;../../../mbed/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2;../../../mbed/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M;../../../mbed/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include;../../../mbed/mbed-os/cmsis/device;../../../mbed/mbed-os/cmsis/device/RTE;../../../mbed/mbed-os/cmsis/device/RTE/include;../../../mbed/mbed-os/cmsis/device/rtos;../../../mbed/mbed-os/connectivity;../../../mbed/mbed-os/connectivity/cellular;../../../mbed/mbed-os/connectivity/drivers;../../../mbed/mbed-os/connectivity/drivers/802.15.4_RF;../../../mbed/mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver;../../../mbed/mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver;../../../mbed/mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver;../../../mbed/mbed-os/connectivity/drivers/cellular;../../../mbed/mbed-os/connectivity/drivers/cellular/Altair;../../../mbed/mbed-os/connectivity/drivers/cellular/Altair/ALT1250;../../../mbed/mbed-os/connectivity/drivers/cellular/Altair/ALT1250/PPP;../../../mbed/mbed-os/connectivity/drivers/cellular/GEMALTO;../../../mbed/mbed-os/connectivity/drivers/cellular/GEMALTO/CINTERION;../../../mbed/mbed-os/connectivity/drivers/cellular/GENERIC;../../../mbed/mbed-os/connectivity/drivers/cellular/GENERIC/GENERIC_AT3GPP;../../../mbed/mbed-os/connectivity/drivers/cellular/MultiTech;../../../mbed/mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano;../../../mbed/mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano/PPP;../../../mbed/mbed-os/connectivity/drivers/cellular/QUECTEL;../../../mbed/mbed-os/connectivity/drivers/cellular/QUECTEL/BC95;../../../mbed/mbed-os/connectivity/drivers/cellular/QUECTEL/BG96;../../../mbed/mbed-os/connectivity/drivers/cellular/QUECTEL/EC2X;../../../mbed/mbed-os/connectivity/drivers/cellular/QUECTEL/M26;../../../mbed/mbed-os/connectivity/drivers/cellular/QUECTEL/UG96;../../../mbed/mbed-os/connectivity/drivers/cellular/RiotMicro;../../../mbed/mbed-os/connectivity/drivers/cellular/RiotMicro/AT;../../../mbed/mbed-os/connectivity/drivers/cellular/TELIT;../../../mbed/mbed-os/connectivity/drivers/cellular/TELIT/HE910;../../../mbed/mbed-os/connectivity/drivers/cellular/TELIT/ME310;../../../mbed/mbed-os/connectivity/drivers/cellular/TELIT/ME910;../../../mbed/mbed-os/connectivity/drivers/cellular/UBLOX;../../../mbed/mbed-os/connectivity/drivers/cellular/UBLOX/AT;../../../mbed/mbed-os/connectivity/drivers/cellular/UBLOX/N2XX;../../../mbed/mbed-os/connectivity/drivers/cellular/UBLOX/PPP;../../../mbed/mbed-os/connectivity/drivers/emac/TARGET_STM;../../../mbed/mbed-os/connectivity/drivers/mbedtls/TARGET_STM;../../../mbed/mbed-os/connectivity/drivers/nfc;../../../mbed/mbed-os/connectivity/drivers/nfc/PN512;../../../mbed/mbed-os/connectivity/drivers/wifi;../../../mbed/mbed-os/connectivity/drivers/wifi/esp8266-driver;../../../mbed/mbed-os/connectivity/libraries;../../../mbed/mbed-os/connectivity/libraries/mbed-coap;../../../mbed/mbed-os/connectivity/libraries/nanostack-libservice;../../../mbed/mbed-os/connectivity/libraries/ppp;../../../mbed/mbed-os/connectivity/lorawan;../../../mbed/mbed-os/connectivity/lwipstack;../../../mbed/mbed-os/connectivity/mbedtls;../../../mbed/mbed-os/connectivity/nanostack;../../../mbed/mbed-os/connectivity/netsocket;../../../mbed/mbed-os/connectivity/nfc;../../../mbed/mbed-os/drivers;../../../mbed/mbed-os/drivers/device_key;../../../mbed/mbed-os/drivers/include;../../../mbed/mbed-os/drivers/include/drivers;../../../mbed/mbed-os/drivers/include/drivers/interfaces;../../../mbed/mbed-os/drivers/usb;../../../mbed/mbed-os/events;../../../mbed/mbed-os/features;../../../mbed/mbed-os/features/frameworks;../../../mbed/mbed-os/features/frameworks/greentea-client;../../../mbed/mbed-os/features/frameworks/mbed-client-cli;../../../mbed/mbed-os/features/frameworks/unity;../../../mbed/mbed-os/features/frameworks/utest;../../../mbed/mbed-os/hal;../../../mbed/mbed-os/hal/include;../../../mbed/mbed-os/hal/include/hal;../../../mbed/mbed-os/hal/usb;../../../mbed/mbed-os/hal/usb/include;../../../mbed/mbed-os/hal/usb/include/usb;../../../mbed/mbed-os/platform;../../../mbed/mbed-os/platform/cxxsupport;../../../mbed/mbed-os/platform/include;../../../mbed/mbed-os/platform/include/platform;../../../mbed/mbed-os/platform/include/platform/internal;../../../mbed/mbed-os/platform/mbed-trace;../../../mbed/mbed-os/platform/mbed-trace/include;../../../mbed/mbed-os/platform/mbed-trace/include/mbed-trace;../../../mbed/mbed-os/platform/randlib;../../../mbed/mbed-os/platform/source;../../../mbed/mbed-os/platform/source/minimal-printf;../../../mbed/mbed-os/rtos;../../../mbed/mbed-os/rtos/include;../../../mbed/mbed-os/rtos/include/rtos;../../../mbed/mbed-os/rtos/include/rtos/internal;../../../mbed/mbed-os/rtos/source;../../../mbed/mbed-os/storage;../../../mbed/mbed-os/storage/blockdevice;../../../mbed/mbed-os/storage/blockdevice/include;../../../mbed/mbed-os/storage/blockdevice/include/blockdevice;../../../mbed/mbed-os/storage/blockdevice/include/blockdevice/internal;../../../mbed/mbed-os/storage/filesystem;../../../mbed/mbed-os/storage/kvstore;../../../mbed/mbed-os/targets/TARGET_STM;../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4;../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW;../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/CMSIS;../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver;../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/Legacy;../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC;../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TARGET_NUCLEO_L432KC
  asm define: ARM_MATH_CM4 EXTRA_IDLE_STACK_REQUIRED MBED_TICKLESS STM32L432xx TRANSACTION_QUEUE_SIZE_SPI=2 USE_FULL_LL_DRIVER USE_HAL_DRIVER __CMSIS_RTOS __CORTEX_M4 __FPU_PRESENT=1 __MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: ../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TOOLCHAIN_ARM/stm32l432xc.sct
  link misc: --library_type=microlib --any_contingency --cpu=Cortex-M4 --inline --keep=os_cb_sections --show_full_path
  group mbed_NUCLEO_L432KC
    ../../../mbed/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Source/: mbed_tz_context.o
    ../../../mbed/mbed-os/drivers/source/: AnalogIn.o AnalogOut.o BufferedSerial.o BusIn.o BusInOut.o BusOut.o CAN.o DigitalIn.o DigitalInOut.o DigitalOut.o FlashIAP.o I2C.o I2CSlave.o InterruptIn.o MbedCRC.o OSPI.o PortIn.o PortInOut.o PortOut.o PwmOut.o QSPI.o ResetReason.o SPI.o SPISlave.o SerialBase.o SerialWireOutput.o Ticker.o Timeout.o Timer.o TimerEvent.o UnbufferedSerial.o Watchdog.o
    ../../../mbed/mbed-os/features/frameworks/mbed-greentea-io/: mbed_io.o
    ../../../mbed/mbed-os/hal/source/: LowPowerTickerWrapper.o mbed_compat.o mbed_critical_section_api.o mbed_flash_api.o mbed_gpio.o mbed_gpio_irq.o mbed_itm_api.o mbed_lp_ticker_api.o mbed_lp_ticker_wrapper.o mbed_pinmap_common.o mbed_pinmap_default.o mbed_ticker_api.o mbed_us_ticker_api.o static_pinmap.o
    ../../../mbed/mbed-os/hal/source/mpu/: mbed_mpu_v7m.o mbed_mpu_v8m.o
    ../../../mbed/mbed-os/hal/usb/source/: mbed_usb_phy.o
    ../../../mbed/mbed-os/platform/cxxsupport/: mstd_mutex.o
    ../../../mbed/mbed-os/platform/mbed-trace/source/: mbed_trace.o
    ../../../mbed/mbed-os/platform/source/: ATCmdParser.o CThunkBase.o CriticalSectionLock.o DeepSleepLock.o FileBase.o FileHandle.o FilePath.o FileSystemHandle.o LocalFileSystem.o Stream.o SysTimer.o mbed_alloc_wrappers.o mbed_application.o mbed_assert.o mbed_atomic_impl.o mbed_board.o mbed_critical.o mbed_error.o mbed_error_hist.o mbed_interface.o mbed_mem_trace.o mbed_mktime.o mbed_mpu_mgmt.o mbed_os_timer.o mbed_poll.o mbed_power_mgmt.o mbed_rtc_time.o mbed_sdk_boot.o mbed_semihost_api.o mbed_stats.o mbed_thread.o mbed_wait_api_no_rtos.o newlib_nano_malloc_workaround.o mbed_retarget.o
    ../../../mbed/mbed-os/platform/source/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.o
    ../../../mbed/mbed-os/platform/source/TARGET_CORTEX_M/: mbed_fault_handler.o
    ../../../mbed/mbed-os/platform/source/minimal-printf/: mbed_printf_armlink_overrides.o mbed_printf_implementation.o mbed_printf_wrapper.o
    ../../../mbed/mbed-os/rtos/source/: ConditionVariable.o EventFlags.o Kernel.o Mutex.o Semaphore.o ThisThread.o Thread.o
    ../../../mbed/mbed-os/storage/blockdevice/source/: BufferedBlockDevice.o ChainingBlockDevice.o ExhaustibleBlockDevice.o FlashSimBlockDevice.o HeapBlockDevice.o MBRBlockDevice.o ObservingBlockDevice.o ProfilingBlockDevice.o ReadOnlyBlockDevice.o SFDP.o SlicingBlockDevice.o
    ../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/Legacy/: stm32l4xx_hal_can_legacy.o
    ../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/: stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_can.o stm32l4xx_hal_comp.o stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.o stm32l4xx_hal_cryp.o stm32l4xx_hal_cryp_ex.o stm32l4xx_hal_dac.o stm32l4xx_hal_dac_ex.o stm32l4xx_hal_dcmi.o stm32l4xx_hal_dfsdm.o stm32l4xx_hal_dfsdm_ex.o stm32l4xx_hal_dma.o stm32l4xx_hal_dma2d.o stm32l4xx_hal_dma_ex.o stm32l4xx_hal_dsi.o stm32l4xx_hal_exti.o stm32l4xx_hal_firewall.o stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gfxmmu.o stm32l4xx_hal_gpio.o stm32l4xx_hal_hash.o stm32l4xx_hal_hash_ex.o stm32l4xx_hal_hcd.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_irda.o stm32l4xx_hal_iwdg.o stm32l4xx_hal_lcd.o stm32l4xx_hal_lptim.o stm32l4xx_hal_ltdc.o stm32l4xx_hal_ltdc_ex.o stm32l4xx_hal_mmc.o stm32l4xx_hal_mmc_ex.o stm32l4xx_hal_nand.o stm32l4xx_hal_nor.o stm32l4xx_hal_opamp.o stm32l4xx_hal_opamp_ex.o stm32l4xx_hal_ospi.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pka.o stm32l4xx_hal_pssi.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_qspi.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rng.o stm32l4xx_hal_rng_ex.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sai.o stm32l4xx_hal_sai_ex.o stm32l4xx_hal_sd.o stm32l4xx_hal_sd_ex.o stm32l4xx_hal_smartcard.o stm32l4xx_hal_smartcard_ex.o stm32l4xx_hal_smbus.o stm32l4xx_hal_smbus_ex.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_sram.o stm32l4xx_hal_swpmi.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_tsc.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o stm32l4xx_hal_usart.o stm32l4xx_hal_usart_ex.o stm32l4xx_hal_wwdg.o stm32l4xx_ll_adc.o stm32l4xx_ll_comp.o stm32l4xx_ll_crc.o stm32l4xx_ll_crs.o stm32l4xx_ll_dac.o stm32l4xx_ll_dma.o stm32l4xx_ll_dma2d.o stm32l4xx_ll_exti.o stm32l4xx_ll_fmc.o stm32l4xx_ll_gpio.o stm32l4xx_ll_i2c.o stm32l4xx_ll_lptim.o stm32l4xx_ll_lpuart.o stm32l4xx_ll_opamp.o stm32l4xx_ll_pka.o stm32l4xx_ll_pwr.o stm32l4xx_ll_rcc.o stm32l4xx_ll_rng.o stm32l4xx_ll_rtc.o stm32l4xx_ll_sdmmc.o stm32l4xx_ll_spi.o stm32l4xx_ll_swpmi.o stm32l4xx_ll_tim.o stm32l4xx_ll_usart.o stm32l4xx_ll_usb.o stm32l4xx_ll_utils.o
    ../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/: system_stm32l4xx.o
    ../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TARGET_NUCLEO_L432KC/: PeripheralPins.o
    ../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TOOLCHAIN_ARM/: startup_stm32l432xx.o
    ../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/: system_clock.o
    ../../../mbed/mbed-os/targets/TARGET_STM/TARGET_STM32L4/: analogin_device.o analogout_device.o flash_api.o gpio_irq_device.o i2c_device.o pwmout_device.o serial_device.o spi_api.o
    ../../../mbed/mbed-os/targets/TARGET_STM/: USBPhy_STM32.o analogin_api.o analogout_api.o can_api.o gpio_api.o gpio_irq_api.o hal_tick_overrides.o i2c_api.o lp_ticker.o mbed_crc_api.o mbed_overrides.o ospi_api.o pinmap.o port_api.o pwmout_api.o qspi_api.o reset_reason.o rtc_api.o serial_api.o sleep.o stm_spi_api.o trng_api.o us_ticker.o watchdog_api.o
    ../../../mbed/: mbed-os-baremetal.ar
  group to_7seg
    ./: to_7seg.cpp
    ./: to_7seg.h
  group C++ Sources
    ./: main.cpp hardware.h hardware.cpp range_finder.h range_finder.cpp switch.h switch.cpp
    ./: pinout.h display.cpp display.h control.cpp control.h
